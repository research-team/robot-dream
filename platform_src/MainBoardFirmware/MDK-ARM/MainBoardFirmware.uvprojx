# Keil uVision project MainBoardFirmware.uvprojx, settings and files
target MainBoardFirmware (ARM-ADS)
  device: STM32F401VCTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: MainBoardFirmware
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c misc: --C99
  c include: ../Inc;C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/STM32F4xx_HAL_Driver/Inc;C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Middlewares/Third_Party/FreeRTOS/Source/include;C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/CMSIS/Include;C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include
  asm include: ..\Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Middlewares/Third_Party/FreeRTOS/Source/: tasks.c croutine.c event_groups.c timers.c list.c queue.c
    C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User
    ../Src/: stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c stm32f4xx_hal_msp.c freertos.c main.c spi.c usart.c gpio.c i2c.c
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Drivers/CMSIS
    C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/yurra/STM32Cube/Repository/STM32Cube_FW_F4_V1.13.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c
software components: CMSIS:CORE 4.1.0
